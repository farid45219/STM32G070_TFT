# Keil uVision project stm32g070_tft.uvprojx, settings and files
target STM32G070RB (6220000::V6.22::ARMCLANG)
  device: STM32G070RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00009000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: stm32g070_tft
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group Device
    ./RTE/_STM32G070RB/: startup_stm32g070xx.s system_stm32g0xx.c
  group FRTOS
    ./: kernel.h kernel.s threads.h threads.c
  group Drivers
    ./: spi.h spi.c
  group inc
    ./: tft.h
  group src
    ./: main.c debug.c tft.c
  group ::CMSIS
    ./: debug.h
software components: CMSIS:CORE 6.2.0
